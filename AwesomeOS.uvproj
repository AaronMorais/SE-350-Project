# Keil uVision project AwesomeOS.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: AwesomeOS
  c flags: Optim=1
  c define: DEBUG_0
  c misc: --c99
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: HAL.c k_memory.c k_process.c k_rtx_init.c main_svc.c printf.c startup_LPC17xx.s system_LPC17xx.c uart_polling.c usr_proc.c priority_queue.c syscall.c heap.c
